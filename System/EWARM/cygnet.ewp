# IAR project cygnet.ewp, settings and files
configuration cygnet (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433CC ST STM32L433CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USING_IAR; STM32L433xx; STM32_THREAD_SAFE_STRATEGY=4; CJSON_NO_CLIB=0
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Utilities/lpm/tiny_lpm; ../Utilities/misc; ../Utilities/timer; ../Utilities/trace/adv_trace; ../Global; ../../App; ../../App/json; ../../App/json/note-c; ../Core/Weak
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: cygnet.hex
  ILINK.IlinkOutputFile: cygnet.out
  ILINK.IlinkIcfFile: stm32l433xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../../App/: app.c button.c config.c diag.c gps.c led.c maintask.c modem.c monitor.c montask.c post.c power.c req.c reqtask.c serial.c work.c
  group Core
    ../Core/Src/: adc.c can.c debug_if.c dma.c flash_if.c gpio.c heap_4.c i2c.c lptim.c main.c rng.c rtc.c spi.c stm32_lpm_if.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c timer_if.c usart.c usb.c wwdg.c
    ../Core/Weak/: app_weak.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_usb.c
  group EWARM
    ./: dlib_lock_glue.c startup_stm32l433xx.s
  group Global
    ../Global/: amd5.c array.c base64.c crc16.c crc32.c debug.c float16.c gerr.c gmem.c loc.c md5hash.c memmem.c mutex.c os.c rand.c rrandom.c strl.c task.c timegm.c timer.c tss.c
  group JSON
    ../../App/json/note-c/: n_b64.c n_cjson.c n_cjson_helpers.c
    ../../App/json/: n_lib.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/misc/: stm32_mem.c
    ../Utilities/timer/: stm32_timer.c
